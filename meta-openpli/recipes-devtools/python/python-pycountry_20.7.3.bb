SUMMARY = "A Python library to access ISO country, subdivision, language, currency and script definitions and their translations."
HOMEPAGE = "https://github.com/flyingcircusio/pycountry"
LICENSE = "LGPLv2.1"
SECTION = "devel/python"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=2e3f24d82bf0f89a5a3be6801b999bf1"

SRC_URI[md5sum] = "55b4727c4ba0219105289c1ce6c9cde0"
SRC_URI[sha256sum] = "81084a53d3454344c0292deebc20fcd0a1488c136d4900312cbd465cf552cb42"


inherit pypi setuptools

